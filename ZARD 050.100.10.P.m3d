# KOMPAS-3D part (ZARD 050.100.10.P.m3d)

Model tree:
1. Операция без истории:1
